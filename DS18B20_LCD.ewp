# IAR project DS18B20_LCD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries; ; Libraries\STM32F7xx_StdPeriph_Driver\inc; Libraries\STM32F7xx_StdPeriph_Driver\src; Users\inc; Users\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: DS18B20_LCD.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f767xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/: core_cm7.h startup_stm32f767xx.s stm32f7xx.h
  group Cpp
    Libraries/STM32F7xx_StdPeriph_Driver/src/: misc.c stm32f7xx_flash.c stm32f7xx_gpio.c stm32f7xx_rcc.c stm32f7xx_tim.c stm32f7xx_usart.c
    Libraries/: system_stm32f7xx.c
  group Users
    Users/src/: DS18B20.cpp LCD.cpp main.cpp mcu_init.cpp UART.cpp
